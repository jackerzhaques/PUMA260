# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk,PART_TM4C1294NCPDT,TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: ..\..\TivaWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project.c startup_rvmdk.S
  group Libraries
    ../../TivaWare/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
